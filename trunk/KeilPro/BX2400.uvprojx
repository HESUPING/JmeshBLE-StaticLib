# Keil uVision project BX2400.uvprojx, settings and files
target ram_code_without_rom (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: BX2400 +hex
  AfterMake: fromelf --bin --output=binary .\Objects\%L
  AfterMake: ..\tools\image_tool\bin_merge.exe ..\tools\image_tool\merge.ini binary\RAM_CODE binary\FLASH_CODE binary\NVDS_AREA boot_ram.bin
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HW_BX_VERSION=2400
  c include: ..\;..\freertos;..\freertos\app;..\freertos\src;..\freertos\src\include;..\freertos\src\portable;..\freertos\src\portable\ARMCC\ARM_CM0;..\ip\ahi\api;..\ip\ble\hl\api;..\ip\ble\hl\inc;..\ip\ble\hl\src\gap;..\ip\ble\hl\src\gap\gapc;..\ip\ble\hl\src\gap\gapm;..\ip\ble\hl\src\gap\smpc;..\ip\ble\hl\src\gap\smpm;..\ip\ble\hl\src\gatt;..\ip\ble\hl\src\gatt\attc;..\ip\ble\hl\src\gatt\attm;..\ip\ble\hl\src\gatt\atts;..\ip\ble\hl\src\gatt\gattc;..\ip\ble\hl\src\gatt\gattm;..\ip\ble\hl\src\l2c;..\ip\ble\hl\src\l2c\l2cc;..\ip\ble\hl\src\l2c\l2cm;..\ip\ble\hl\src\prf;..\ip\ble\hl\src\rwble_hl;..\ip\ea\api;..\ip\em\api;..\ip\hci\api;..\ip\hci\src;..\modules\app\api;..\modules\app\src;..\modules\common\api;..\modules\dbg\api;..\modules\display\api;..\modules\display\src;..\modules\ecc_p256\api;..\modules\h4tl\api;..\modules\ke\api;..\modules\ke\src;..\modules\nvds\api;..\modules\rf\api;..\modules\rwip\api;..\plf\inc;..\plf\inc\cmsis;..\plf\bx_debug;..\plf\bx_debug\log;..\plf\bx_debug\log\RTT;..\ip\ble\profiles\anp;..\ip\ble\profiles\anp\anpc\api;..\ip\ble\profiles\anp\anpc\src;..\ip\ble\profiles\anp\anps\api;..\ip\ble\profiles\anp\anps\src;..\ip\ble\profiles\bas;..\ip\ble\profiles\bas\basc\api;..\ip\ble\profiles\bas\basc\src;..\ip\ble\profiles\bas\bass\api;..\ip\ble\profiles\bas\bass\src;..\ip\ble\profiles\blp;..\ip\ble\profiles\blp\blpc\api;..\ip\ble\profiles\blp\blpc\src;..\ip\ble\profiles\blp\blps\api;..\ip\ble\profiles\blp\blps\src;..\ip\ble\profiles\bxota;..\ip\ble\profiles\bxota\bxotac\api;..\ip\ble\profiles\bxota\bxotac\src;..\ip\ble\profiles\bxota\bxotas\api;..\ip\ble\profiles\bxota\bxotas\src;..\ip\ble\profiles\cpp;..\ip\ble\profiles\cpp\cppc\api;..\ip\ble\profiles\cpp\cppc\src;..\ip\ble\profiles\cpp\cpps\api;..\ip\ble\profiles\cpp\cpps\src;..\ip\ble\profiles\cscp;..\ip\ble\profiles\cscp\cscpc\api;..\ip\ble\profiles\cscp\cscpc\src;..\ip\ble\profiles\cscp\cscps\api;..\ip\ble\profiles\cscp\cscps\src;..\ip\ble\profiles\dis;..\ip\ble\profiles\dis\disc\api;..\ip\ble\profiles\dis\disc\src;..\ip\ble\profiles\dis\diss\api;..\ip\ble\profiles\dis\diss\src;..\ip\ble\profiles\find;..\ip\ble\profiles\find\findl\api;..\ip\ble\profiles\find\findl\src;..\ip\ble\profiles\find\findt\api;..\ip\ble\profiles\find\findt\src;..\ip\ble\profiles\glp;..\ip\ble\profiles\glp\glpc\api;..\ip\ble\profiles\glp\glpc\src;..\ip\ble\profiles\glp\glps\api;..\ip\ble\profiles\glp\glps\src;..\ip\ble\profiles\hrp;..\ip\ble\profiles\hrp\hrpc\api;..\ip\ble\profiles\hrp\hrpc\src;..\ip\ble\profiles\hrp\hrps\api;..\ip\ble\profiles\hrp\hrps\src;..\ip\ble\profiles\htp;..\ip\ble\profiles\htp\htpc\api;..\ip\ble\profiles\htp\htpc\src;..\ip\ble\profiles\htp\htpt\api;..\ip\ble\profiles\htp\htpt\src;..\ip\ble\profiles\lan;..\ip\ble\profiles\lan\lanc\api;..\ip\ble\profiles\lan\lanc\src;..\ip\ble\profiles\lan\lans\api;..\ip\ble\profiles\lan\lans\src;..\ip\ble\profiles\pasp;..\ip\ble\profiles\pasp\paspc\api;..\ip\ble\profiles\pasp\paspc\src;..\ip\ble\profiles\pasp\pasps\api;..\ip\ble\profiles\pasp\pasps\src;..\ip\ble\profiles\prox;..\ip\ble\profiles\prox\proxm\api;..\ip\ble\profiles\prox\proxm\src;..\ip\ble\profiles\prox\proxr\api;..\ip\ble\profiles\prox\proxr\src;..\ip\ble\profiles\rscp;..\ip\ble\profiles\rscp\rscpc\api;..\ip\ble\profiles\rscp\rscpc\src;..\ip\ble\profiles\rscp\rscps\api;..\ip\ble\profiles\rscp\rscps\src;..\ip\ble\profiles\scpp;..\ip\ble\profiles\scpp\scppc\api;..\ip\ble\profiles\scpp\scppc\src;..\ip\ble\profiles\scpp\scpps\api;..\ip\ble\profiles\scpp\scpps\src;..\ip\ble\profiles\tip;..\ip\ble\profiles\tip\tipc\api;..\ip\ble\profiles\tip\tipc\src;..\ip\ble\profiles\tip\tips\api;..\ip\ble\profiles\tip\tips\src;..\ip\ble\profiles\hogp;..\ip\ble\profiles\hogp\hogpbh\api;..\ip\ble\profiles\hogp\hogpbh\src;..\ip\ble\profiles\hogp\hogpd\api;..\ip\ble\profiles\hogp\hogpd\src;..\ip\ble\profiles\hogp\hogprh\api;..\ip\ble\profiles\hogp\hogprh\src;..\ip\ble\ll\src\rwble;..\ip\ble\ll\src\em;..\ip\ble\ll\src\llc;..\ip\ble\ll\src\lld;..\ip\ble\ll\src\llm;..\plf\peripheral\;..\plf\peripheral\swint;..\plf\peripheral\ssi;..\plf\peripheral\ssi\app_qspi;..\plf\peripheral\ssi\app_spi;..\plf\peripheral\rtc;..\plf\peripheral\led;..\plf\peripheral\hw_ecc;..\plf\peripheral\flash;..\plf\peripheral\app_uart;..\plf\peripheral\sleep_recovery;..\plf\peripheral\app_dmac;..\plf\peripheral\app_hwecc;..\plf\bx2400\src;..\plf\bx2400\src\arch;..\plf\bx2400\src\arch\boot\armcc;..\plf\bx2400\src\arch\compiler\armcc;..\plf\bx2400\src\arch\ll\;..\plf\bx2400\src\build\ble-full\reg\fw;..\plf\bx2400\src\jmp_table;..\plf\bx2400\src\patch_list;..\plf\bx2400\src\sleep;..\plf\bx2400\src\inc;..\plf\bx2400\src\arch\boot\armcc;..\plf\bx2400\src\peripheral_integration\cache;..\plf\bx2400\src\peripheral_integration\dmac;..\plf\bx2400\src\peripheral_integration\hwecc;..\plf\bx2400\src\peripheral_integration\qspi;..\plf\bx2400\src\peripheral_integration\rtc;..\plf\bx2400\src\peripheral_integration\uart;..\plf\bx2400\src\sys_integration\clk_gate;..\plf\bx2400\src\sys_integration\modem;..\plf\bx2400\src\sys_integration\patch;..\plf\bx2400\src\sys_integration\periph_mngt;..\plf\bx2400\src\sys_integration\pshare;..\plf\bx2400\src\sys_integration\rc_calib;..\plf\bx2400\src\sys_integration\rst_gen;..\plf\bx2400\src\sys_integration\swint;..\plf\bx2400\src\sys_integration\sysctrl;..\plf\bx2400\src\peripheral_integration\spi;..\plf\bx_debug\internal_log;..\plf\peripheral\app_gpio;..\plf\peripheral\flash_cache;..\..\jmeshBLE\src\app\gate;..\..\jmeshBLE\src\app\light;..\..\jmeshBLE\src\app\meter;..\..\jmeshBLE\src\app\realcomm;..\..\jmeshBLE\src\app\water;..\..\jmeshBLE\src\foundation\state;..\..\jmeshBLE\src\access;..\..\jmeshBLE\src\upper;..\..\jmeshBLE\src\upper\control;..\..\jmeshBLE\src\upper\lowpower;..\..\jmeshBLE\src\upper\routing;..\..\jmeshBLE\src\lower;..\..\jmeshBLE\src\network;..\..\jmeshBLE\src\bearer\adv;..\..\jmeshBLE\src\bearer\beacon;..\..\jmeshBLE\src\bearer\gatt;..\..\jmeshBLE\src\bearer\provisioning;..\..\jmeshBLE\src\driver;..\..\jmeshBLE\src\driver\bx2400;..\..\jmeshBLE\src\jmesh;..\..\jmeshBLE\src\onchip_system;..\..\jmeshBLE\src\secure;..\..\jmeshBLE\src\secure\AES_CMAC\base;..\..\jmeshBLE\src\secure\AES_CMAC\toolbox;..\..\jmeshBLE\src\secure\ECDH;..\..\jmeshBLE\src\BLE;..\..\jmeshBLE\src\foundation\config;..\..\jmeshBLE\src\foundation\cmd;..\..\jmeshBLE\src\app\realcomm;..\..\jmeshBLE\src\app\light;..\..\jmeshBLE\src\app\meter;..\plf\peripheral\app_pwm;..\plf\bx2400\src\peripheral_integration\pwm;..\..\jmeshBLE\src\app\test_app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\plf\bx2400\config\linker_script\armcc\fw_usr.txt
  link misc: ..\plf\bx2400\config\rom_syms_armcc.txt --datacompressor=off
  group app_with_freertos
    ../freertos/app/: ble_task.c os_bridge.c osapp_adv.c osapp_advdata_change.c osapp_advintv_change.c osapp_bond_master.c osapp_bond_slave.c osapp_connparam_change.c osapp_demo.c osapp_dis_client.c osapp_dis_server.c osapp_findt.c osapp_gble.c osapp_gble_itf.c osapp_scan.c osapp_selfie.c osapp_task.c osapp_template.c osapp_utils.c periph_task.c task_init.c osapp_1M2M_master.c osapp_1M2M_slave.c osapp_mi_scale.c osapp_uart_server.c osapp_throughput_client.c osapp_throughput_server.c
  group app_without_freertos
    ../modules/app/src/: app.c app_batt.c app_dis.c app_display.c app_hid.c app_ht.c app_sec.c app_task.c
  group freertos_src
    ../freertos/src/portable/MemMang/: heap_4.c
    ../freertos/src/: event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/src/portable/ARMCC/ARM_CM0/: port.c
  group arch
    ../plf/bx2400/src/arch/main/: arch_main.c
    ../plf/bx2400/src/arch/boot/armcc/: startup_bx2400.s
  group ble
    ../ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../ip/ble/ll/src/lld/: bx_lld_sleep.c
    ../ip/ble/ll/src/rwble/: bx_rwble.c
  group profiles
    ../ip/ble/profiles/anp/anpc/src/: anpc.c anpc_task.c
    ../ip/ble/profiles/anp/anps/src/: anps.c anps_task.c
    ../ip/ble/profiles/bas/basc/src/: basc.c basc_task.c
    ../ip/ble/profiles/bas/bass/src/: bass.c bass_task.c
    ../ip/ble/profiles/blp/blpc/src/: blpc.c blpc_task.c
    ../ip/ble/profiles/blp/blps/src/: blps.c blps_task.c
    ../ip/ble/profiles/bxota/bxotas/src/: bxotas.c bxotas_task.c
    ../ip/ble/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    ../ip/ble/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    ../ip/ble/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    ../ip/ble/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    ../ip/ble/profiles/dis/disc/src/: disc.c disc_task.c
    ../ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
    ../ip/ble/profiles/find/findt/src/: findt.c findt_task.c
    ../ip/ble/profiles/find/findl/src/: findl.c findl_task.c
    ../ip/ble/profiles/glp/glpc/src/: glpc.c glpc_task.c
    ../ip/ble/profiles/glp/glps/src/: glps.c glps_task.c
    ../ip/ble/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    ../ip/ble/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ../ip/ble/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    ../ip/ble/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    ../ip/ble/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    ../ip/ble/profiles/htp/htpc/src/: htpc.c htpc_task.c
    ../ip/ble/profiles/htp/htpt/src/: htpt.c htpt_task.c
    ../ip/ble/profiles/lan/lanc/src/: lanc.c lanc_task.c
    ../ip/ble/profiles/lan/lans/src/: lans.c lans_task.c
    ../ip/ble/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    ../ip/ble/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    ../ip/ble/profiles/prox/proxm/src/: proxm.c proxm_task.c
    ../ip/ble/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ../ip/ble/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    ../ip/ble/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    ../ip/ble/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    ../ip/ble/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    ../ip/ble/profiles/tip/tips/src/: tips.c tips_task.c
    ../ip/ble/profiles/tip/tipc/src/: tipc.c tipc_task.c
  group modules
    ../modules/dbg/src/: dbg.c dbg_mwsgen.c dbg_swdiag.c dbg_task.c
    ../modules/display/src/: display.c display_task.c
    ../modules/ecc_p256/src/: ecc_p256.c
    ../modules/nvds/src/: nvds_in_ram.c nvds_tag.c
    ../modules/rf/src/: rf_bluex.c
    ../modules/rwip/src/: rwip.c
    ../modules/common/src/: bx_ring_queue.c
  group utils
    ../plf/bx2400/src/jmp_table/: Hbeacon.c jump_table.c
    ../plf/bx2400/src/patch_list/: patch_test.c tx_test_end.c patch_list.s adv_int.c h4tl_patch.c prog_latency_patch.c set_adv_payload_31Byte_patch.c h4tl_patch_asm.s
    ../plf/bx2400/src/sleep/: sys_sleep.c sys_sleep_ram.c
    ../plf/bx_debug/: bx_dbg.c
    ../plf/bx_debug/log/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../plf/bx_debug/log/: sim_log.c
    ../plf/bx_debug/armcc/: bx_dbg_asm.s
  group integration
    ../plf/bx2400/src/sys_integration/clk_gate/: clk_gate.c
    ../plf/bx2400/src/sys_integration/modem/: modem.c
    ../plf/bx2400/src/sys_integration/patch/: patch.c
    ../plf/bx2400/src/sys_integration/periph_mngt/: periph_mngt.c
    ../plf/bx2400/src/sys_integration/pshare/: pshare.c
    ../plf/bx2400/src/sys_integration/rc_calib/: rc_calib.c
    ../plf/bx2400/src/sys_integration/rst_gen/: rst_gen.c
    ../plf/bx2400/src/sys_integration/sysctrl/: rf_reg_settings_2400.c sysctrl.c touch.c io_ctrl.c
    ../plf/bx2400/src/peripheral_integration/cache/: cache_integration.c
    ../plf/bx2400/src/peripheral_integration/dmac/: dmac_integration.c
    ../plf/bx2400/src/peripheral_integration/hwecc/: hwecc_integration.c
    ../plf/bx2400/src/peripheral_integration/qspi/: qspi_integration.c
    ../plf/bx2400/src/peripheral_integration/rtc/: rtc_integration.c
    ../plf/bx2400/src/peripheral_integration/uart/: uart_integration.c
    ../plf/bx2400/src/peripheral_integration/spi/: spi_integration.c
    ../plf/bx2400/src/peripheral_integration/gpio/: gpio_integration.c
    ../plf/bx2400/src/peripheral_integration/pwm/: pwm_integration.c
  group peripheral
    ../plf/peripheral/app_dmac/: app_dmac.c app_dmac_wrapper.c
    ../plf/peripheral/app_hwecc/: app_hwecc.c app_hwecc_wrapper.c
    ../plf/peripheral/app_uart/: app_uart.c
    ../plf/peripheral/flash/: flash.c
    ../plf/peripheral/flash_cache/: flash_cache.c
    ../plf/peripheral/sleep_recovery/: periph_recovery.c
    ../plf/peripheral/ssi/app_qspi/: app_qspi.c app_qspi_wrapper.c
    ../plf/peripheral/ssi/app_spi/: app_spi.c
    ../plf/peripheral/app_gpio/: app_gpio.c
    ../plf/peripheral/app_pwm/: app_pwm.c
  group app
    ../../jmeshBLE/src/app/realcomm/: realcomm_client.c realcomm_client_callback.c realcomm_config.c realcomm_config_callback.c realcomm_server.c realcomm_server_callback.c
    ../../jmeshBLE/src/app/light/: light_client.c light_client_callback.c light_config.c light_config_callback.c light_server.c light_server_callback.c
    ../../jmeshBLE/src/app/meter/: meter_client.c meter_client_callback.c meter_config.c meter_server.c meter_server_callback.c protocol_645.c
    ../../jmeshBLE/src/app/test_app/: test_app_client.c test_app_client_callback.c test_app_config.c test_app_config_callback.c test_app_server.c test_app_server_callback.c
  group foundation
    ../../jmeshBLE/src/foundation/config/: config_client.c config_client_callback.c config_server.c config_server_callback.c config_client_app.c configuration_cmd.c
    ../../jmeshBLE/src/foundation/state/: jmesh_appkey.c jmesh_bind.c jmesh_subscription_list.c jmesh_TTL.c jmesh_state.c
  group access
    ../../jmeshBLE/src/access/: jmesh_access.c jmesh_access_callback.c jmesh_message.c jmesh_element.c jmesh_model.c
  group upper
    ../../jmeshBLE/src/upper/control/: jmesh_control.c jmesh_heartbeat.c
    ../../jmeshBLE/src/upper/lowpower/: jmesh_friendship.c jmesh_friend.c jmesh_lowpower.c
    ../../jmeshBLE/src/upper/: jmesh_upper.c
    ../../jmeshBLE/src/upper/routing/: jmesh_routing.c jmesh_routing_neighbor_table.c jmesh_routing_table.c
  group lower
    ../../jmeshBLE/src/lower/: jmesh_lower.c jmesh_segment.c
  group network
    ../../jmeshBLE/src/network/: jmesh_filter.c jmesh_interface.c jmesh_netkey.c jmesh_network.c jmesh_relay.c jmesh_seq.c
  group bearer
    ../../jmeshBLE/src/bearer/adv/: jmesh_adv.c
    ../../jmeshBLE/src/bearer/beacon/: jmesh_beacon.c jmesh_beacon_callback.c jmesh_device_beacon.c jmesh_routing_beacon.c jmesh_secure_beacon.c
    ../../jmeshBLE/src/bearer/gatt/: jmesh_gatt.c jmesh_gatt_callback.c jmesh_proxy.c jmesh_proxy_config.c
    ../../jmeshBLE/src/bearer/provisioning/: jmesh_provisioning_client.c jmesh_provisioning_server.c jmesh_provisioning.c jmesh_provisioning_callback.c
  group driver
    ../../jmeshBLE/src/driver/bx2400/: bx2400_ble.c bx2400_gpio.c bx2400_pwm.c bx2400_save.c bx2400_system.c bx2400_uart.c
    ../../jmeshBLE/src/driver/: jmesh_ble_callback.c jmesh_gpio_int_callback.c jmesh_uart_callback.c
  group jmesh
    ../../jmeshBLE/src/jmesh/: jmesh_addr.c jmesh_device.c jmesh_features.c jmesh_pdu.c jmesh_print.c jmesh_task.c
  group onchip_system
    ../../jmeshBLE/src/onchip_system/: os_callback.c os_core.c os_demo.c os_list.c os_main.c os_memb.c os_queue.c os_ram.c os_time.c os_timer.c os_timer_event.c
  group secure
    ../../jmeshBLE/src/secure/AES_CMAC/base/: aes128.c aes128_ccm.c aes128_cmac.c
    ../../jmeshBLE/src/secure/AES_CMAC/toolbox/: security_kn.c
    ../../jmeshBLE/src/secure/ECDH/: uECC.c
    ../../jmeshBLE/src/secure/: jmesh_security.c
  group ble_adapt
    ../../jmeshBLE/src/BLE/: BLE_adapt.c jmeshc.c jmeshc_task.c jmeshs_prov.c jmeshs_prov_task.c jmeshs_app.c jmeshs_app_task.c
  group StaticLib
    ../../jmeshBLE/src/: BX2400.lib
